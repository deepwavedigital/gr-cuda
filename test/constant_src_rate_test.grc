<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_samples</value></param>
<param><key>value</key><value>131072</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>num_samples</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mintime</key><value>1000.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>num_samples</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>200e6</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>cuda_gpu_kernel</key>
<param><key>id</key><value>cuda_gpu_kernel_0</value></param>
<param><key>device_num</key><value>0</value></param>
<param><key>io_type</key><value>float</value></param>
<param><key>threads_per_block</key><value>128</value></param>
<param><key>vlen</key><value>num_samples</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>cuda_gpu_kernel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cuda_gpu_kernel_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
