<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>divide_by_two</value></param>
<param><key>author</key><value>Deepwave Digital</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>AIR-T Example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>buffer_size</value></param>
<param><key>value</key><value>16384</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>31.25e6</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>buffer_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>buffer_size</value></param>
</block>
<block>
<key>cuda_gpu_kernel</key>
<param><key>id</key><value>cuda_gpu_kernel_0</value></param>
<param><key>device_num</key><value>0</value></param>
<param><key>io_type</key><value>complex</value></param>
<param><key>threads_per_block</key><value>128</value></param>
<param><key>vlen</key><value>buffer_size</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>Input Signal (Real)</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>color2</key><value>"green"</value></param>
<param><key>label2</key><value>Input Signal (Imag)</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>color3</key><value>"Dark Blue"</value></param>
<param><key>label3</key><value>Output Signal (Real)</value></param>
<param><key>width3</key><value>2</value></param>
<param><key>color4</key><value>"magenta"</value></param>
<param><key>label4</key><value>Output Signal (Imag)</value></param>
<param><key>width4</key><value>2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>512</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Signal Amplitude</value></param>
<param><key>ymax</key><value>0.11</value></param>
<param><key>ymin</key><value>-0.11</value></param>
</block>
<block>
<key>soapy_source</key>
<param><key>id</key><value>soapy_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>dc_offset_auto_mode0</key><value>True</value></param>
<param><key>gain_auto_mode0</key><value>True</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offset0</key><value>0</value></param>
<param><key>correction0</key><value>0</value></param>
<param><key>fine_tune0</key><value>False</value></param>
<param><key>overall_gain0</key><value>0</value></param>
<param><key>balance0</key><value>0</value></param>
<param><key>lna_gain0</key><value>0</value></param>
<param><key>mix_gain0</key><value>0</value></param>
<param><key>pga_gain0</key><value>0</value></param>
<param><key>tuner_gain0</key><value>0</value></param>
<param><key>vga_gain0</key><value>0</value></param>
<param><key>ant1</key><value></value></param>
<param><key>dc_offset_auto_mode1</key><value>False</value></param>
<param><key>gain_auto_mode1</key><value>False</value></param>
<param><key>fine_tune1</key><value>False</value></param>
<param><key>overall_gain1</key><value>0</value></param>
<param><key>lna_gain1</key><value>0</value></param>
<param><key>mix_gain1</key><value>0</value></param>
<param><key>pga_gain1</key><value>0</value></param>
<param><key>tuner_gain1</key><value>0</value></param>
<param><key>vga_gain1</key><value>0</value></param>
<param><key>dev</key><value>"driver=SoapyAIRT"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>cuda_gpu_kernel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>cuda_gpu_kernel_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>soapy_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>soapy_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
